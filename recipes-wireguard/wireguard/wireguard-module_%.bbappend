# Use a fork of the wireguard-linux-compat library that removes the kernel version checks.
SRC_URI = "https://github.com:oxin-ros/wireguard-linux-compat;protocol=https;branch=main"
