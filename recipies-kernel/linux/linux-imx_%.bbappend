# Add custom kernel options for wireguard, wireless PCI
SRC_URI += "file://wireguard-extra-kernel-options.cfg"
